# Keil uVision project Project.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F030x8,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\System;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../System/: py32f030xx_ll_Start_Kit.c startup_py32f030xx.s system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c
  group Doc
    ../: readme.txt
